## drivers/hello/Kconfig
```kconfig
menu "Hello Drivers"

config HELLO
  tristate "Hello World"
  default y

endmenu
```
